COMPATIBLE_MACHINE:qemu-generic-arm64 = "qemu-generic-arm64"
